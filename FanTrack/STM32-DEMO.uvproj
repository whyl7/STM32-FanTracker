# Keil uVision project STM32-DEMO.uvproj, settings and files
target LCD-TOUCH-DEMO (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\FWlib\src;..\CMSIS\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c lcd.c systick.c ff.c sdcard.c diskio.c sd_fs_app.c SPI_Flash.c Touch.c Sd_bmp.c 24l01.c led.c
    ../CMSIS/: system_stm32f10x.c
  group FWlib
    ../FWlib/src/: stm32f10x_spi.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c misc.c stm32f10x_systick.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_sdio.c
  group CMSIS
    ../CMSIS/: core_cm3.c
  group Tips
    ./: 提示.txt
